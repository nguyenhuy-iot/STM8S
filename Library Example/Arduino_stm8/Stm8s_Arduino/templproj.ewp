# IAR project templproj.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: inc; DriverLib\inc
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: templproj.bin
  ILINK.IlinkOutputFile: STM8_Arduino.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S103; NDEBUG
  ICCSTM8.CCIncludePath2: inc
  OBJCOPY.OOCOutputFile: Demo.srec
  group (top)
    ./: Sketch.cpp
  group DriverLib/inc
    DriverLib/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group DriverLib/src
    DriverLib/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group inc
    inc/: Arduino.h EEPROM.h Print.h Printable.h Rand.h Serial.h stm8s.h stm8s_conf.h
  group src
    src/: Arduino.cpp EEPROM.cpp main.cpp preinit.cpp Print.cpp Rand.cpp Serial.cpp
