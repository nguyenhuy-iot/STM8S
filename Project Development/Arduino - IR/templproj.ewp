# IAR project templproj.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: inc; UserFile
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: Test.bin
  ILINK.IlinkOutputFile: STM8_Arduino.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S103; NDEBUG
  ICCSTM8.CCIncludePath2: inc
  OBJCOPY.OOCOutputFile: Demo.srec
  group (top)
    ./: Sketch.cpp
  group inc
    inc/: Arduino.h EEPROM.h Print.h Printable.h Rand.h Serial.h stm8s.h
  group src
    src/: Arduino.cpp EEPROM.cpp main.cpp preinit.cpp Print.cpp Rand.cpp Serial.cpp
  group UserFile
    UserFile/: IRremote.cpp IRremote.h
